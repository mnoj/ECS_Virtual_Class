options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test_out.ts
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '6048'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '8192'
    type: complex
  states: {state: disabled}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: 64qam
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: 64qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_demod_reference_signals_0
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    constellation: 64qam
    guard_interval: GI_1_4
    hierarchy: nh
    include_cell_id: cell_id_no
    transmission_mode: T8k
    type: complex
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_ofdm_sym_acquisition_0
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    cp_length: '2048'
    fft_length: '8192'
    occupied_tones: '6817'
    snr: '20'
    type: complex
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: 64qam
    hierarchy: nh
    type: b
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8192'
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.rectangular(8192)
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: 526e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 9.1429e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 9.1429e6
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '70'
    interp: '64'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [blocks_correctiq_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [blocks_correctiq_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [blocks_vector_to_stream_1, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [blocks_vector_to_stream_1_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', dtv_dvbt_demap_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_file_sink_0, '0']
- [dtv_dvbt_ofdm_sym_acquisition_0, '0', fft_vxx_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_1_0, '0']
- [fft_vxx_0, '0', dtv_dvbt_demod_reference_signals_0, '0']
- [osmosdr_source_1, '0', blocks_correctiq_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1

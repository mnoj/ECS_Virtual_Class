options:
  parameters:
    generate_options: qt_gui
    id: fm_tx
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '0.00005'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '62'
    value: '20'
    widget: dial
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if_gain
    rangeType: int
    start: '1'
    step: '1'
    stop: '40'
    value: '40'
    widget: dial
  states: {}
- name: mpx_rate
  id: variable
  parameters:
    value: '160000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '14'
    value: '14'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '87500000'
    step: '100000'
    stop: '108000000'
    value: '94700000'
  states: {}
- name: tx_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_preemph_1
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '.980'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\bcpmosaj\OneDrive - UPV EHU\0_2025.2026\KSE\Dev\GNU_Radio\oihu.wav
    repeat: 'True'
    type: short
    vlen: '2'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: short
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: mpx_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HANN
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: tx_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: tx_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: mpx_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: tx_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: mpx_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: mpx_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: mpx_rate
    interp: tx_rate
    taps: ''
    type: ccf
  states: {}

connections:
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_preemph_1, '0', rational_resampler_xxx_1, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_fm_preemph_1, '0']
- [blocks_multiply_const_vxx_2, '0', rational_resampler_xxx_3, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_to_streams_0, '0', blocks_short_to_float_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_short_to_float_1, '0']
- [low_pass_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_3, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_3, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
